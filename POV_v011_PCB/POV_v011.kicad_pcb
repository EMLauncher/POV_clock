# Repository EMLauncher/POV_clock

## KiCad design POV_v011_PCB/POV_v011.kicad_pcb

Parts:
C1: 0.1u; C_1206_3216Metric
C2, C3, C4: 0.1u; C_1206_3216Metric; not fitted
C5, C6, C7, C8, C11, C12: 4.7u; C_0603_1608Metric
C9, C10, C14, C20: 0.1u; C_0603_1608Metric
C13: 680p; C_0603_1608Metric
C21: 1u; C_0603_1608Metric
C22, C23: 10p; C_0603_1608Metric
C41: 0.01u; C_0603_1608Metric
D1, D2, D4: BAT54HT1G; D_SOD-323
D3: 15V; D_SMA; not fitted
D10, D11, D12, D13, D14, D15, D16, D17, D20, D21, D22, D23, D24, D25, D26, D27, D30, D31, D32, D33, D34, D35, D36, D37, D40, D41, D42, D43, D44, D45, D46, D47: BL; D_0603_1608Metric
J1: SWD; PinHeader_1x04_P2.54mm_Vertical
L1: PCB_coil; PCB_Coil_R15_L2T12
L2: 10u; L_1210_3225Metric
Q1, Q2, Q3, Q4: DTC123E; SOT-323_SC-70
R1: 5.6k; R_0603_1608Metric
R2: 3.3k; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R10, R11, R12, R13, R14, R15, R16, R17: 510; R_0603_1608Metric
R20, R21: 100; R_0603_1608Metric
R41: 2.2k; R_0603_1608Metric
R45: 1k; R_0603_1608Metric
SW1: min--; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
SW2: min++; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
SW3: hour--; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
SW4: hour++; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: NJM1933; SOT-23-6
U2: STM32C011F4P6; TSSOP-20_4.4x6.5mm_P0.65mm
U3: U18; PinHeader_1x03_P1.27mm_Vertical
Y1: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V: C10.1, C11.1, C12.1, C13.1, C14.1, C20.1, C21.1, J1.4, L2.2, R1.1, R3.1, R41.1, U2.4 (VDD), U3.1 (VCC)
/PhZ: R3.2, U2.1 (PB7), U3.3 (VOUT)
/SW: C41.1, R45.1, U2.6 (PF2)
/dig0: Q1.1 (B), U2.15 (PA8)
/dig1: Q2.1 (B), U2.16 (PA9/PA11)
/dig2: Q3.1 (B), U2.17 (PA10/PA12)
/dig3: Q4.1 (B), U2.20 (PB6)
GND: C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C20.2, C21.2, C22.2, C23.2, C41.2, D2.2 (A), D3.2 (A), D4.2 (A), J1.1, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), R2.2, U1.2 (GND), U2.5 (VSS), U3.2 (GND)
LED0: D10.2 (A), D20.2 (A), D30.2 (A), D40.2 (A), R10.2
LED1: D11.2 (A), D21.2 (A), D31.2 (A), D41.2 (A), R11.2
LED2: D12.2 (A), D22.2 (A), D32.2 (A), D42.2 (A), R12.2
LED3: D13.2 (A), D23.2 (A), D33.2 (A), D43.2 (A), R13.2
LED4: D14.2 (A), D24.2 (A), D34.2 (A), D44.2 (A), R14.2
LED5: D15.2 (A), D25.2 (A), D35.2 (A), D45.2 (A), R15.2
LED6: D16.2 (A), D26.2 (A), D36.2 (A), D46.2 (A), R16.2
LED7: D17.2 (A), D27.2 (A), D37.2 (A), D47.2 (A), R17.2
unnamed: C1.1, C2.1, C3.1, C4.1, L1.2
unnamed: C5.2, C6.1, C7.2, C8.1, L1.1
unnamed: C1.2, C2.2, C3.2, C4.2, D1.2 (A), D2.1 (K)
unnamed: D4.1 (K), L2.1, U1.6 (SW)
unnamed: D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), Q1.3 (C), SW1.1
unnamed: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), Q2.3 (C), SW2.1
unnamed: D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), Q3.3 (C), SW3.1
unnamed: D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), Q4.3 (C), SW4.1
unnamed: J1.2, R21.2
unnamed: J1.3, R20.2
unnamed: R41.2, R45.2, SW1.2, SW2.2, SW3.2, SW4.2
unnamed: C13.2, R1.2, R2.1, U1.3 (FB)
unnamed: R10.1, U2.7 (PA0)
unnamed: R11.1, U2.8 (PA1)
unnamed: R12.1, U2.9 (PA2)
unnamed: R13.1, U2.10 (PA3)
unnamed: R14.1, U2.11 (PA4)
unnamed: R15.1, U2.12 (PA5)
unnamed: R16.1, U2.13 (PA6)
unnamed: R17.1, U2.14 (PA7)
unnamed: R20.1, U2.18 (PA13)
unnamed: R21.1, U2.19 (PA14)
unnamed: C22.1, U2.2 (PC14), Y1.1
unnamed: C23.1, U2.3 (PC15), Y1.2
VCC: C5.1, C7.1, C9.1, D1.1 (K), D3.1 (K), U1.4 (SHDN), U1.5 (VIN)

Notes on the sheet:
共振キャパシタはC0G

Board: 2 copper layers, 200.0 x 60.0 mm, 85 parts (1 on the bottom side), 41 nets.

## KiCad design POV_TX_PCB/POV_TX.kicad_pcb

Parts:
C1: 0.1u; C_1206_3216Metric
C2: 1n; C_0603_1608Metric
C3, C20: 0.1u; C_0603_1608Metric
C4, C21: 10u; C_0603_1608Metric
C10: 1u; C_0603_1608Metric
J1: USB_C_PD_6P; USB_C_Receptacle_GCT_USB4125-xx-x-0190_6P_TopMnt_Horizontal
L1: 30u; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
M1: Motor; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
R1, R2: 47k; R_0603_1608Metric
R3: 9.1k; R_0603_1608Metric
R10: 10k; R_0603_1608Metric
R11: 1k; R_0603_1608Metric
R12, R13: 5.1k; R_0603_1608Metric
R20: 20k; R_0603_1608Metric
R21: 6.8k; R_0603_1608Metric
U1: XKT-510; SOIC-8_3.9x4.9mm_P1.27mm
U10: CH221K; SOT-23-6
U20: BD621xF; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, C3.1, C4.1, C20.1, C21.1, J1.A9 (VBUS), J1.B9 (VBUS), L1.2, R1.1, R2.1, R11.1, R20.1, U1.1 (VDD), U20.2 (VCC), U20.3 (VCC), U20.4 (FIN)
GND: C3.2, C4.2, C10.2, C20.2, C21.2, J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), R12.2, R13.2, R21.2, U1.4 (GND), U10.2 (GND), U20.5 (RIN), U20.8 (GND)
unnamed: J1.A5 (CC1), R12.1, U10.4 (CC1)
unnamed: J1.B5 (CC2), R13.1, U10.5 (CC2)
unnamed: C1.2, L1.1, U1.3 (OUT)
unnamed: M1.1, U20.7 (OUT2)
unnamed: M1.2, U20.1 (OUT1)
unnamed: C2.1, R1.2, U1.6 (AIN)
unnamed: R3.2, U1.7 (FIN)
unnamed: C2.2, R2.2, R3.1, U1.8 (XXX)
unnamed: R10.2, U10.6 (CFG)
unnamed: C10.1, R10.1, R11.2, U10.1 (VDD)
unnamed: R20.2, R21.1, U20.6 (VREF)

Notes on the sheet:
BLK
R10=10k:5V
R21=6.8k ~ 10k
RED

Board: 2 copper layers, 25.0 x 25.0 mm, 22 parts (0 on the bottom side), 13 nets.

## Code that names these connections

File POV_v011/POV_v011.ioc (part):

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Mcu.Name=STM32C011F(4-6)Px
Mcu.Package=TSSOP20
Mcu.UserName=STM32C011F4Px
PA0.GPIOParameters=GPIO_Speed
PA0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA0.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_Speed
PA1.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA1.Signal=GPIO_Output
PA11\ [PA9].GPIOParameters=GPIO_Speed
PA11\ [PA9].GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA11\ [PA9].Signal=GPIO_Output
PA12\ [PA10].GPIOParameters=GPIO_Speed
PA12\ [PA10].GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA12\ [PA10].Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=DEBUG_SWDIO
PA14-BOOT0.Mode=Serial_Wire
PA14-BOOT0.Signal=DEBUG_SWCLK
PA2.GPIOParameters=GPIO_Speed
PA2.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA2.Signal=GPIO_Output
PA3.GPIOParameters=GPIO_Speed
PA3.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA3.Signal=GPIO_Output
PA4.GPIOParameters=GPIO_Speed
PA4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Speed
PA5.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Speed
PA6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Speed
PA7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Speed
PA8.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA8.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_Speed
PB6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB6.Signal=GPIO_Output
PB7.Signal=GPIO_Input
PC14-OSCX_IN\ (PC14).Mode=LSE-External-Oscillator
PC14-OSCX_IN\ (PC14).Signal=RCC_OSCX_IN
PC15-OSCX_OUT\ (PC15).Mode=LSE-External-Oscillator
PC15-OSCX_OUT\ (PC15).Signal=RCC_OSCX_OUT
PF2-NRST.Signal=GPIO_Input
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=48000000
board=custom

File POV_v011/Core/Src/main.c (part):

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  MX_GPIO_Init();
  MX_RTC_Init();
  /* USER CODE BEGIN 2 */
  GPIOF->MODER &= GPIO_MODER_MODE2; // CubeMX does not initialize PF2. PF2:input mode.

  omegaPI.u = OMEGA_MIN; // initialize minimum omega
  omegaTs = __CALC_OMEGATS(omegaPI.u);
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  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, GPIO_PIN_RESET);

  /*Configure GPIO pin : PB7 */
  GPIO_InitStruct.Pin = GPIO_PIN_7;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

  /*Configure GPIO pin : PF2 */
  GPIO_InitStruct.Pin = GPIO_PIN_2;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOF, &GPIO_InitStruct);

  /*Configure GPIO pins : PA0 PA1 PA2 PA3
                           PA4 PA5 PA6 PA7
                           PA8 PA11 PA12 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7
                          |GPIO_PIN_8|GPIO_PIN_11|GPIO_PIN_12;
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  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pin : PB6 */
  GPIO_InitStruct.Pin = GPIO_PIN_6;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
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	return;
}

// EXTI for PB7
static void EXTI_init(void) {
	// initialize EXTI
	EXTI->FTSR1 |= EXTI_FTSR1_FT7; // falling edge enable on Line 7
	EXTI->EXTICR[1] |= (0x01 << EXTI_EXTICR1_EXTI3_Pos); // select PB7
	EXTI->IMR1 |= EXTI_IMR1_IM7; // disable CPU wake-up mask Line7
	NVIC_EnableIRQ(EXTI4_15_IRQn); // enable interrupt on Line 4 to 15
	return;
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	// turn ON selected digit & turn OFF previous digit
	switch (digit) {
	case 0:
		if (!(GPIOF->IDR & (1UL << 2))) { // PF2 (SW pin) is 0
			sw_status = HOUR_INC_FLAG;
		}
		GPIOB->ODR &= ~DIG3_msk; // turn OFF DIG3
		dispPix.v = dispPixels[theta_idx];
		const_delay(); // not for display ghost
		GPIOA->ODR |= (LED8BIT_msk & dispPix.b[2]); // update pixel
		GPIOA->ODR |= DIG0_msk; // turn ON DIG0
		break;
	case 1:
		if (!(GPIOF->IDR & (1UL << 2))) {
			sw_status = MIN_DEC_FLAG;
		}
		GPIOA->ODR &= ~DIG0_msk; // turn OFF DIG0
		dispPix.v = dispPixels[theta_idx];
		const_delay(); // not for display ghost
		GPIOA->ODR |= (LED8BIT_msk & dispPix.b[3]);
		GPIOA->ODR |= DIG1_msk; // turn ON DIG1
		break;
	case 2:
		if (!(GPIOF->IDR & (1UL << 2))) {
			sw_status = MIN_INC_FLAG;
		}
		GPIOA->ODR &= ~DIG1_msk; // turn OFF DIG1
		dispPix.v = dispPixels[(theta_idx + (THETA_RESL >> 1)) % THETA_RESL]; // add to theta 180 deg.
		const_delay(); // not for display ghost
		GPIOA->ODR |= (LED8BIT_msk & dispPix.b[0]);
		GPIOA->ODR |= DIG2_msk; // turn ON DIG2
		break;
	case 3:
		if (!(GPIOF->IDR & (1UL << 2))) {
			sw_status = HOUR_DEC_FLAG;
		}
		GPIOA->ODR &= ~DIG2_msk; // turn OFF DIG2
		dispPix.v = dispPixels[(theta_idx + (THETA_RESL >> 1)) % THETA_RESL];
		const_delay(); // not for display ghost
		GPIOA->ODR |= (LED8BIT_msk & dispPix.b[1]);
		GPIOB->ODR |= DIG3_msk; // turn ON DIG3
		break;
	default:
		// do nothing
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

Notices in the files:
POV_v011/Core/Src/main.c:
Copyright (c) 2024 STMicroelectronics.
All rights reserved.
This software is licensed under terms that can be found in the LICENSE file
